# Keil uVision project milandr_first.uvprojx, settings and files
target test (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MDR32F9Q2I Milandr
  pack: Milandr.MDR32FxQI.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: milandr_first +hex
  AfterMake: cmd /c copy Obj\*.hex .
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\libraries\CMSIS\CM3\CoreSupport;.\libraries\CMSIS\CM3\DeviceSupport\MDR32F9Qx\inc;.\libraries\CMSIS\CM3\DeviceSupport\MDR32F9Qx\startup\arm;.\libraries\MDR32F9Qx_StdPeriph_Driver\inc;.\libraries\PT;.\core\src;.\core\inc;.\Time64
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group core
    ./core/src/: CAN.c Main.c MDR32F9Qx_it.c MNP_msg.c Retarget.c ring_buffer.c pins.c uart_func.c systick.c timers.c MDR32F9Qx_can_helper.c
    ./core/inc/: HW_Profile.h protocol.h Retarget.h typedef.h
  group libraries
    ./libraries/MDR32F9Qx_StdPeriph_Driver/src/: MDR32F9Qx_adc.c MDR32F9Qx_arinc429r.c MDR32F9Qx_arinc429t.c MDR32F9Qx_audio.c MDR32F9Qx_bkp.c MDR32F9Qx_can.c MDR32F9Qx_comp.c MDR32F9Qx_dac.c MDR32F9Qx_dma.c MDR32F9Qx_ebc.c MDR32F9Qx_eeprom.c MDR32F9Qx_i2c.c MDR32F9Qx_iwdg.c MDR32F9Qx_keypad.c MDR32F9Qx_led.c MDR32F9Qx_port.c MDR32F9Qx_power.c MDR32F9Qx_rst_clk.c MDR32F9Qx_ssp.c MDR32F9Qx_timer.c MDR32F9Qx_uart.c MDR32F9Qx_usb.c MDR32F9Qx_wwdg.c
  group startup
    ./libraries/CMSIS/CM3/DeviceSupport/MDR32F9Qx/startup/arm/: system_MDR32F9Qx.c startup_MDR32F9Qx.s
  group time64
    ./Time64/: time64.c
